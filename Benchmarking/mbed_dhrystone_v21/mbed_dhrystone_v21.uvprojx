# Keil uVision project mbed_dhrystone_v21.uvprojx, settings and files
target mbed_dhrystone_v21 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: CPUTYPE("Cortex-M0+")
  output: mbed_dhrystone_v21
  AfterMake: C:\Keil_V5\ARM\ARMCC\bin\fromelf.exe --bin --output=BUILD/mbed_dhrystone_v21.bin BUILD/mbed_dhrystone_v21.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=7 wLevel=2
  c define: DEVICE_PORTIN=1 DEVICE_SERIAL=1 DEVICE_PORTINOUT=1 MBED_BUILD_TIMESTAMP=1632873259.3462498 DEVICE_ANALOGIN=1 __ASSERT_MSG TOOLCHAIN_ARM DEVICE_STDIO_MESSAGES=1 __CMSIS_RTOS DEVICE_I2C=1 TARGET_KL25Z DEVICE_SLEEP=1 MBED_ROM_SIZE=0x20000 MBED_MINIMAL_PRINTF TARGET_LIKE_CORTEX_M0 TARGET_M0P TARGET_CORTEX_M TARGET_Freescale ARM_MATH_CM0PLUS TARGET_FF_ARDUINO TARGET_CORTEX MBED_ROM_START=0x0 __CORTEX_M0PLUS TOOLCHAIN_ARMC6 MULADDC_CANNOT_USE_R7 DEVICE_SPISLAVE=1 DEVICE_I2CSLAVE=1 DEVICE_SEMIHOST=1 TOOLCHAIN_ARM_STD TARGET_NAME=KL25Z DEVICE_ANALOGOUT=1 DEVICE_PORTOUT=1 MBED_TRAP_ERRORS_ENABLED=1 DEVICE_SPI=1 DEVICE_INTERRUPTIN=1 DEVICE_USTICKER=1 DEVICE_PWMOUT=1 TARGET_RELEASE MBED_RAM_SIZE=0x4000 __MBED__=1 TARGET_KLXX MBED_RAM_START=0x1ffff000 __MBED_CMSIS_RTOS_CM TARGET_LIKE_MBED
  c misc: --no_rtti --cpu=Cortex-M0plus -c --split_sections --no_depend_system_headers --md --gnu --apcs=interwork --preinclude=mbed_config.h
  c include: ;/usr/src/mbed-sdk;mbed;mbed/TARGET_KL25Z;mbed/TARGET_KL25Z/TARGET_Freescale;mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX;mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX/TARGET_KL25Z;mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX/TARGET_KL25Z/device;mbed/drivers;mbed/hal;mbed/platform
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-DARM_MATH_CM0PLUS,-D__MBED_CMSIS_RTOS_CM,-D__CORTEX_M0PLUS,-D__CMSIS_RTOS
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/MKL25Z4.sct
  link misc: --show_full_path --predefine="-DXIP_ENABLE=0" --predefine="-DMBED_RAM_START=0x1ffff000" --keep=os_cb_sections --legacyalign --predefine="-DMBED_RAM_SIZE=0x4000" --predefine="-DMBED_ROM_SIZE=0x20000" --predefine="-DMBED_BOOT_STACK_SIZE=4096" --cpu=Cortex-M0plus --predefine="-DMBED_ROM_START=0x0" --inline --any_contingency
  group mbed
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h Serial.h SerialBase.h SPI.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h
    mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h Driver_Common.h Driver_Storage.h emac_api.h ethernet_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/: analogin_api.o analogout_api.o cmsis_nvic.o gpio_api.o gpio_irq_api.o i2c_api.o mbed.ar mbed_board.o mbed_overrides.o PeripheralPins.o pinmap.o port_api.o pwmout_api.o retarget.o rtc_api.o serial_api.o sleep.o spi_api.o startup_MKL25Z4.o sys.o system_MKL25Z4.o us_ticker.o
    mbed/TARGET_KL25Z/: arm_common_tables.h arm_const_structs.h arm_math.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h
    mbed/platform/: Callback.h CallChain.h CircularBuffer.h critical.h CThunk.h FunctionPointer.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_preprocessor.h mbed_stats.h platform.h PlatformMutex.h rtc_time.h semihost_api.h SingletonPtr.h toolchain.h Transaction.h wait_api.h
    mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX/: clk_freqs.h gpio_object.h objects.h PeripheralPins.h PortNames.h
    mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX/TARGET_KL25Z/device/: cmsis.h cmsis_nvic.h MKL25Z4.h system_MKL25Z4.h
    mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX/TARGET_KL25Z/: device.h PeripheralNames.h PinNames.h
    mbed/: mbed.h
    mbed/TARGET_KL25Z/TARGET_Freescale/: mbed_rtx.h
  group mbed_dhrystone_v21
    ./: dhry.h dhry_2.cpp main.cpp mbed_config.h
